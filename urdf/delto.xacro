Commit message: correct typos

File: urdf/delto.xacro (robot description, xacro)
@@ -7,5 +7,5 @@
   <xacro:include filename="$(find delto)/urdf/delto.gazebo" />
   <link name="world"/>
-  <joint name="base_link"
+  <joint name="base_joint"
     type="fixed">
     <origin
